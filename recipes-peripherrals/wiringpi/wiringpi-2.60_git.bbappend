FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-prepaired-Makefiles-for-yocto.patch \
            file://0001-added-additional-headers-and-c-files.patch \
            file://0001-updated-Makefile.patch \
            "

