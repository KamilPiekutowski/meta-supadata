FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-added-.gitignore-and-afew-modifications.patch"

