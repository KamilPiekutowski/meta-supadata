FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://memdev-stict-disabled.cfg \
    "
